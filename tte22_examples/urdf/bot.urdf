Commit message: Modified URDF and created kinematics example node

File: tte22_examples/urdf/bot.urdf (robot description, URDF)
Before this commit: robot bot, 7 links, 6 joints
Links:
- link ee_link: geometry 
Joints:
- joint link_5_to_ee_link: axis 1 0 0 -> 0 0 1
